#include <stdint.h>

/* =========================================================
 * STM32L476RG - 挑戰 C：長短按控制 LED
 *
 * PA5  (D13)：LED 輸出
 * PA10 (D2) ：按鈕輸入
 *
 * 短按 (< 800ms)：切換 LED 開關
 * 長按 (>= 800ms)：LED 開始閃爍
 * 持續長按：每 250ms 切換 LED 亮滅
 * 放開長按：恢復長按前的 LED 狀態
 * ========================================================= */


/* =========================================================
 * 1. 暫存器定義
 * ========================================================= */

#define REG32(addr) (*(volatile uint32_t *)(addr))

/* RCC */
#define RCC_AHB2ENR  REG32(0x4002104C)

/* GPIOA */
#define GPIOA_MODER  REG32(0x48000000)
#define GPIOA_OTYPER REG32(0x48000004)
#define GPIOA_PUPDR  REG32(0x4800000C)
#define GPIOA_IDR    REG32(0x48000010)
#define GPIOA_BSRR   REG32(0x48000018)

/* Cortex-M4 SysTick */
#define SYST_CSR     REG32(0xE000E010)
#define SYST_RVR     REG32(0xE000E014)
#define SYST_CVR     REG32(0xE000E018)


/* =========================================================
 * 2. 時脈設定
 * ========================================================= */

/* 修正：不再依賴 SystemCoreClock */

#define SYSCLK_HZ 4000000U


/* =========================================================
 * 3. 時間設定
 * ========================================================= */

#define LONG_PRESS_MS 800U
#define BLINK_MS      250U
#define DEBOUNCE_MS    30U


/* =========================================================
 * 4. LED 控制函式
 * ========================================================= */

void LED_Set(uint32_t state)
{
    if (state)
    {
        /* PA5 輸出 HIGH：LED 亮 */
        GPIOA_BSRR = (1U << 5);
    }
    else
    {
        /* PA5 輸出 LOW：LED 滅 */
        GPIOA_BSRR = (1U << 21);
    }
}


/* =========================================================
 * 5. 主程式
 * ========================================================= */

int main(void)
{
    /* -----------------------------------------------------
     * A. 啟用 GPIOA 時脈
     * ----------------------------------------------------- */

    RCC_AHB2ENR |= (1U << 0);


    /* -----------------------------------------------------
     * B. PA5 設定為輸出
     * ----------------------------------------------------- */

    /* 預設輸出 LOW */
    GPIOA_BSRR = (1U << 21);

    /* PA5 設定為一般輸出模式 */
    GPIOA_MODER &= ~(3U << 10);
    GPIOA_MODER |=  (1U << 10);

    /* PA5 設定為推挽輸出 */
    GPIOA_OTYPER &= ~(1U << 5);


    /* -----------------------------------------------------
     * C. PA10 設定為輸入
     * ----------------------------------------------------- */

    GPIOA_MODER &= ~(3U << 20);

    /* 啟用 PA10 內部上拉電阻 */
    GPIOA_PUPDR &= ~(3U << 20);
    GPIOA_PUPDR |=  (1U << 20);


    /* -----------------------------------------------------
     * D. 初始 LED 關閉
     * ----------------------------------------------------- */

    LED_Set(0);


    /* -----------------------------------------------------
     * E. 設定 SysTick 計時器
     * ----------------------------------------------------- */

    /* 先停止 SysTick */
    SYST_CSR = 0;

    /*
     * 4 MHz / 1000 = 4000
     * Reload = 3999
     *
     * 每 1ms 完成一次計數週期
     */

    SYST_RVR = (SYSCLK_HZ / 1000U) - 1U;

    /* 清除目前計數值 */
    SYST_CVR = 0;

    /*
     * Bit 2 = 1：使用核心時脈
     * Bit 0 = 1：啟動 SysTick
     */

    SYST_CSR = (1U << 2) | (1U << 0);


    /* -----------------------------------------------------
     * F. 狀態變數
     * ----------------------------------------------------- */

    /* 毫秒計數 */
    uint32_t ms = 0;

    /* 按下時間 */
    uint32_t press_start = 0;

    /* 上次閃爍時間 */
    uint32_t blink_start = 0;

    /* 防彈跳時間 */
    uint32_t debounce_start = 0;

    /* 上一次讀取到的按鈕狀態 */
    uint32_t previous_raw = 0;

    /* 經過防彈跳確認的按鈕狀態 */
    uint32_t stable_pressed = 0;

    /* LED 原本的開關狀態 */
    uint32_t led_state = 0;

    /* 閃爍時使用的 LED 狀態 */
    uint32_t blink_state = 0;

    /* 是否進入長按模式 */
    uint32_t long_mode = 0;


    /* =====================================================
     * G. 主迴圈
     * ===================================================== */

    while (1)
    {
        /* -----------------------------------------------
         * 1. 更新毫秒計數
         * ----------------------------------------------- */

        if (SYST_CSR & (1U << 16))
        {
            ms++;
        }


        /* -----------------------------------------------
         * 2. 讀取按鈕
         * ----------------------------------------------- */

        /*
         * PA10 = 1：沒有按下
         * PA10 = 0：按鈕按下
         */

        uint32_t raw_pressed =
            (GPIOA_IDR & (1U << 10)) == 0U;


        /* -----------------------------------------------
         * 3. 偵測按鈕訊號變化
         * ----------------------------------------------- */

        if (raw_pressed != previous_raw)
        {
            debounce_start = ms;
            previous_raw = raw_pressed;
        }


        /* -----------------------------------------------
         * 4. 按鈕防彈跳處理
         * ----------------------------------------------- */

        if ((ms - debounce_start) >= DEBOUNCE_MS)
        {
            if (raw_pressed != stable_pressed)
            {
                stable_pressed = raw_pressed;

                /* 按鈕剛按下 */
                if (stable_pressed)
                {
                    press_start = ms;
                    long_mode = 0;
                }

                /* 按鈕剛放開 */
                else
                {
                    if (long_mode == 0)
                    {
                        /*
                         * 短按：
                         * 切換 LED 開關狀態
                         */

                        led_state ^= 1U;
                    }

                    /*
                     * 恢復 LED 的一般狀態
                     */
                    LED_Set(led_state);
                }
            }
        }


        /* -----------------------------------------------
         * 5. 按鈕持續按住
         * ----------------------------------------------- */

        if (stable_pressed)
        {
            /* 判斷是否達到長按門檻 */

            if (long_mode == 0 &&
                (ms - press_start) >= LONG_PRESS_MS)
            {
                /* 進入長按模式 */

                long_mode = 1;

                /* 開始閃爍 */
                blink_state = 1;

                /* 記錄開始閃爍時間 */
                blink_start = ms;

                LED_Set(blink_state);
            }


            /* -------------------------------------------
             * 6. 長按閃爍模式
             * ------------------------------------------- */

            if (long_mode)
            {
                if ((ms - blink_start) >= BLINK_MS)
                {
                    /* 更新閃爍時間 */
                    blink_start = ms;

                    /* 切換亮滅 */
                    blink_state ^= 1U;

                    /* 更新 LED */
                    LED_Set(blink_state);
                }
            }
        }
    }
}
